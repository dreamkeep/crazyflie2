# Keil uVision project crazyflie2-nrf-firmware.uvprojx, settings and files
target crazyflie2 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: crazyflie2-nrf-firmware +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD,NRF51,RSSI_ACK_PACKET,BLE=1,S110=1,
  c misc: --gnu
  c include: .\Include;.\Include\gcc;.\interface;.\nrf51_sdk\nrf51822\Include;.\nrf51_sdk\nrf51822\Include\ble;.\nrf51_sdk\nrf51822\Include\ble\ble_services;.\nrf51_sdk\nrf51822\Include\ble\device_manager;.\s110\s110_nrf51822_7.0.0_API\include;.\s110\Include;.\nrf51_sdk\nrf51822\Include\app_common;.\nrf51_sdk\nrf51822\Include\sd_common;.\nrf51_sdk\nrf51822\Include\sdk
  memory RVCT4: ROM 0x16000 size 0x24000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group NRF51_SDK
    ./nrf51_sdk/nrf51822/Source/ble/: ble_advdata.c ble_conn_params.c
    ./nrf51_sdk/nrf51822/Source/ble/ble_services/: ble_dis.c ble_srv_common.c
    ./nrf51_sdk/nrf51822/Source/sd_common/: softdevice_handler.c
    ./nrf51_sdk/nrf51822/Source/app_common/: app_timer.c pstorage.c
    ./nrf51_sdk/nrf51822/Source/ble/device_manager/: device_manager_peripheral.c
  group src
    ./src/ble/: ble.c ble_crazyflies.c timeslot.c
    ./src/: button.c ds28e05.c ds2431.c esb.c main.c memory.c ow.c pm.c swd.c syslink.c uart.c systick.c
    ./src/ow/: crcutil.c owlnk.c ownet.c owtran.c
    ./: system_nrf51.c arm_startup_nrf51.s
